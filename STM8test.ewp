# IAR project STM8test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\stm8s\StdPeriph_lib; E:\stm8s\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8test.srec
  ILINK.IlinkOutputFile: STM8test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/: DS1307.c DS1307.h font.c font.h i2c.c i2c.h main.c main.h max7219.c max7219.h
  group Std_PeriphLib
    StdPeriph_lib/: stm8s.h stm8s_clk.c stm8s_clk.h stm8s_conf.h stm8s_exti.c stm8s_exti.h stm8s_flash.c stm8s_flash.h stm8s_gpio.c stm8s_gpio.h stm8s_i2c.c stm8s_i2c.h stm8s_it.c stm8s_it.h stm8s_spi.c stm8s_spi.h stm8s_tim1.c stm8s_tim1.h stm8s_tim2.c stm8s_tim2.h stm8s_wwdg.c stm8s_wwdg.h
